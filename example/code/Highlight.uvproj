# Keil uVision project Highlight.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: Highlight +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Bsp;.\Bsp\disp_i2c;.\Bsp\pcf8576c
  group Source Group 1
    ./: STARTUP.A51
  group App
    ./App/: main_task.c
  group Bsp
    ./Bsp/time/: time.c
    ./Bsp/disp_i2c/: disp_iic.c
    ./Bsp/pcf8576c/: lcd_watch.c pcf8576c.c
